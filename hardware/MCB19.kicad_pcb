# Repository ZeniteSolar/MCB19

File README.md:

# MCB19

**M**ódulo **C**arregamento das **B**aterias 2019 

Embarcação Guarapuvu II

Equipe Zênite Solar

### LICENSES

- All firmware (unless otherwise noted), [is licensed under GPL-3.0 or any later version](https://www.gnu.org/licenses/gpl.html)
- All hardware is [licensed under CERN-OHL-S v2 or any later version](https://ohwr.org/cern_ohl_s_v2)

### Sobre

Este módulo é responsável por carregar e gerenciar a carga da bateria auxiliar (rádio e bombas de porão) e da bateria extra (direção elétrica) a partir da energia da bateria principal.

#### Requisitos

1. Carregar a bateria

   - Carregar por CC e CV
      - Controlar a tensao com controlador PI em cascata com controlador PI de corrente.

   - Proteções
      - Sobrecorrente na entrada e saída
      - Curto-circuito na entrada e saída
      - Sobre/sub-tensão na entrada e saída
      - Não permitir corrente da saída para a entrada: Um relé em série com a carga é usado para permitir a leitura da tensão na saída antes de entregar corrente para ela, seguindo as seguintes regras:
        - Somente ligar o relé da saída quando o sistema estiver em regime (sem oscilações na entrada ou na saída).
        - Somente ligar o relé da saída quando a tensão na bateria estiver em niveis dentro do esperado. 

2. Monitoramento do estado das baterias

   - Enviar pela rede CAN:
      - Corrente de carga
      - Tensão da bateria
      - Tensão da bateria principal
### Abordagens

 1. Especificação do conversor
   - Tensão de entrada: 30-50V
   - Corrente de saida: 8A
   - Tensão de saida: 10-15V

   Como no sistema, a tensão da bateria principal (entrada) será sempre maior que a tensão a tenão da bateria extra/auxiliar (saída), foi escolhido projetar um conversor estatico CC-CC Buck, com chaveamento síncrono (dois mosfets) para maior obter eficiencia.
   #### [Projeto do Buck](https://github.com/ZeniteSolar/MCB19/blob/master/control/buck.ipynb)
   
   - Para as condições especificadas anteriormente foram escolhidos:
      - Capacitor de saida: 200uF
      - Indutor de saida 300uH
 2. Controlador
   - Por sua simplicidade de implementação e por permitir ajustes empíricos, controladores PI foram escolhidos para controlar tanto a tensão de saída quanto a corrente de saída.
   
   [Referencia](https://e2e.ti.com/cfs-file/__key/communityserver-discussions-components-files/902/PI-controller-equations.pdf)
 
 3. Simulações
   - Para a simulação foi usado o programa Psim pois ele oferece a simulação de bloco C onde foi possivel simular de uma forma simplificada o comportamento do atmega328p, alem de ter ferramentas para controle.

<table width="100%">
  <tr>
    <th width="35%"> </th>
    <th width="65%"></th>
  </tr>
</table>

   4. Hardware
   - Para o design da Placa de circuito impresso (PCB) foi utilizado o software KiCad por ser uma ferramenta OpenSource. A PCB foi fabricada usando transferencia termica.
   
   #### É importante a utilização de snubber para amortecer os picos de tensão nas chaves
   
   5. Firmware
   - A cada interrupção do ADC é chamada a função de controle. Ao finalizar a maquina de estados é executada onde as mensagens CAN são enviadas e recebidas.
   
### [src/conf.h](firmware/src/conf.h)

Configurações gerais do sistema
```C
//#Definições do conversor
#define VO_SETPOINT 	13.2
#define IO_MAX      	8
#define VI_MIN      	21
```
### [src/adc.c](firmware/src/adc.c)
   No arquivo adc.c são lidos os valores dos ADCs e convertidos a valores "humanos", tambem é chamada a função de controle
   - Coeficientes de linearização
      - Com estes coeficientes é convertido o valor lido pelo ADC em uma unidade de medida 
```C
    static const float vi_coeff = 0.06582490575070313f;                                         
    static const float vo_coeff = 0.06717781789490249f;                          
    static const float io_coeff = 0.01599315004f; 
```
### [src/control.c](firmware/src/control.c)
   No arquivo control.c é executado o algoritmo de controle (PiVo em cascata com PiIo), para sintonizar o controlador tem que mudar as constantes Kp e Ti

```C

/*          PI CONTROL ALGORITHM - SERIES IMPLEMENTATION
** /desc    Algoritimo para Controlador Proporcional Integrativo Diferencial.
**  ref1: 
https://e2e.ti.com/cfs-file/__key/communityserver-discussions-components-files/902/PI-controller-equations.pdf

** /var r é o valor desejado para a saída, o 'set-point'.
** /var y é o valor da saída.
** /ret     retorna a ação de controle u.
*/
inline float piVo(float r, float y){
    // PI CONFIGURATIONS:
    const float Kp = 0.5;           // analog series proportional gain
    const float Ti = 0.1;          // analog series integration period
    const float Ts = PERIOD;        // digital sampling period

    // INTERNAL CONSTANTS COMPUTATION:
    const float a0 = -Kp;           // IIR coefficient for old sample
    const float a1 = Kp*(1+Ts/Ti);  // IIR coefficient for new sample

    // CONTROLLER STATIC VARIABLES
    static float e0 = 0;            // old error
    static float e1 = 0;            // new error
    static float u = 0;             // control action

    // Compute error:
    e0 = e1;
    e1 = r -y;

    // Compute control action:
    u += + a1*e1 + a0*e0;

    return u;
}

inline float piIo(float r, float y){
    // PI CONFIGURATIONS:
    const float Kp = 0.001;         // analog series proportional gain
    const float Ti = 0.001;         // analog series integration period
    const float Ts = PERIOD;        // digital sampling period

    // INTERNAL CONSTANTS COMPUTATION:
    const float a0 = -Kp;           // IIR coefficient for old sample
    const float a1 = Kp*(1+Ts/Ti);  // IIR coefficient for new sample

    // CONTROLLER STATIC VARIABLES
    static float e0 = 0;            // old error
    static float e1 = 0;            // new error
    static float u = 0;             // control action

    // Compute error:
    e0 = e1;
    e1 = r -y;

    // Compute control action:
    u += + a1*e1 + a0*e0;

    // Anti windup
    if(u < D_MIN)           u = D_MIN;
    else if(u > D_MAX)      u = D_MAX;

    return u;
}
```
### [src/machine.c](firmware/src/control.c)
   No arquivo machine.c é executada a maquina de estados

```C
inline void machine_run(void)                                                    
{                                                                                   
    if(print_adc){ print_infos(); print_adc = 0;}                                   
                                                                                    
    if(machine_clk){                                                                
        machine_clk = 0;                                                            
                                                                                    
        if(error_flags.all){                                                        
            print_system_flags();                                                   
            print_error_flags();                                                    
            print_infos();                                                          
            set_state_error();                                                      
        }                                                                           
                                                                                    
        switch(state_machine){                                                      
            case STATE_INITIALIZING:                                                
                task_initializing();                                                
                                                                                    
                break;                                                              
            case STATE_IDLE:                                                        
                task_idle();                                                                    
                                                                                    
                break;                                                              
            case STATE_RUNNING:                                                     
                task_running();                                                     
                #ifdef CAN_ON                                                       
                    can_app_task();                                                 
                #endif /* CAN_ON */                                                 
                                                                                    
                break;                                                              
            case STATE_ERROR:                                                       
                task_error();                                                       
                                                                                    
            case STATE_RESET:                                                       
            default:                                                                
                task_reset();                                                       
                break;                                                              
        }                                                                           
    }                                                                               
}                
```

## KiCad design hardware/MCB19.kicad_pcb

Parts:
F501: 500mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder

Connections:
/CANBUS CONN/CAN_18V: F501.2; also elsewhere on the board
VCC: F501.1; also elsewhere on the board

Parts:
C201, C202, C205: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C203, C204: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D201: pesd1can; SOT-23_Handsoldering
R201: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R202: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R203: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP201: SI; TestPoint_Pad_2.0x2.0mm
TP202: SO; TestPoint_Pad_2.0x2.0mm
TP203: TXCAN; TestPoint_Pad_2.0x2.0mm
TP204: RXCAN; TestPoint_Pad_2.0x2.0mm
TP205: SC; TestPoint_Pad_2.0x2.0mm
TP206: SCK; TestPoint_Pad_2.0x2.0mm
TP207: CAN_H; TestPoint_Pad_2.0x2.0mm
TP208: CAN_L; TestPoint_Pad_2.0x2.0mm
TP209: INT; TestPoint_Pad_2.0x2.0mm
U201: MCP2551-I/SN; SOIC-8_3.9x4.9mm_P1.27mm
U202: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
Y201: 16MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C201.1, C202.1, C205.1, R203.1, U201.3 (VDD), U202.18 (VDD); also elsewhere on the board
/CANBUS CONN/CAN_H: D201.1, R201.2, TP207.1, U201.7 (CANH); also elsewhere on the board
/CANBUS CONN/CAN_L: D201.2, R201.1, TP208.1, U201.6 (CANL); also elsewhere on the board
/CANBUS/RXCAN: TP204.1, U201.4 (RXD), U202.2 (RXCAN)
/CANBUS/TXCAN: TP203.1, U201.1 (TXD), U202.1 (TXCAN)
/MCU/MCP_INT: TP209.1, U202.12 (~INT); also elsewhere on the board
/MCU/MCP_SS: TP205.1, U202.16 (~CS); also elsewhere on the board
/MISO: TP202.1, U202.15 (SO); also elsewhere on the board
/MOSI: TP201.1, U202.14 (SI); also elsewhere on the board
/SCK: TP206.1, U202.13 (SCK); also elsewhere on the board
unnamed: R202.1, U201.8 (STBY)
unnamed: C204.1, U202.8 (OSC1), Y201.2
unnamed: C203.1, U202.7 (OSC2), Y201.1
unnamed: R203.2, U202.17 (~RESET)

Notes on the sheet:
EMI/ESD Protection Solutions for the CAN Bus: https://www.onsemi.com/pub/Collateral/AND8169-D.PDF SparkFun CAN-Bus Shield: https://cdn.sparkfun.com/datasheets/Dev/Arduino/Shields/SparkFun_CAN-Bus_Shield_v13a.pdf

Parts:
C401, C402, C406, C407, C408, C409: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C403, C404: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3, D6, D7: ESD5Zxx; D_SOD-523
D401: LL4148; D_MiniMELF_Handsoldering
D402, D403: LED_RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J401: USART; PinHeader_1x04_P2.54mm_Vertical
J402: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Vertical
R401, R407, R408, R409, R410: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R402, R403: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R404, R406: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R411: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP401: PWM; TestPoint_Pad_2.0x2.0mm
TP402: ENABLE; TestPoint_Pad_2.0x2.0mm
U401: ATmega328-P; DIP-28_W7.62mm_LongPads
Y401: 16MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C401.1, C402.2, D401.1 (K), R401.2, U401.7 (VCC), U401.20 (AVCC), U401.21 (AREF); also elsewhere on the board
/MCU/ENABLE: TP402.1, U401.4 (PD2); also elsewhere on the board
/MCU/INALLL: R407.1; also elsewhere on the board
/MCU/LM324_A: R408.2; also elsewhere on the board
/MCU/LM324_B: R409.2; also elsewhere on the board
/MCU/MCP_INT: U401.15 (PB1); also elsewhere on the board
/MCU/MCP_SS: U401.14 (PB0); also elsewhere on the board
/MCU/PWM: TP401.1, U401.16 (PB2); also elsewhere on the board
/MCU/RESET: C406.1, D401.2 (A), J401.4, R401.1, R411.1
/MCU/USART_RX: R402.1, U401.2 (PD0)
/MCU/USART_TX: R403.1, U401.3 (PD1)
/MISO: U401.18 (PB4); also elsewhere on the board
/MOSI: U401.17 (PB3); also elsewhere on the board
/SCK: U401.19 (PB5); also elsewhere on the board
unnamed: C407.2, D3.1 (K), R407.2, U401.23 (PC0)
unnamed: C408.1, D6.1 (K), R408.1, U401.24 (PC1)
unnamed: C409.1, D7.1 (K), R409.1, U401.25 (PC2)
unnamed: D402.2 (A), R404.2
unnamed: D403.2 (A), R406.2
unnamed: J401.2, R403.2
unnamed: J401.3, R402.2
unnamed: J402.1, R410.1, U401.11 (PD5)
unnamed: R404.1, U401.6 (PD4)
unnamed: R406.1, U401.13 (PD7)
unnamed: C404.1, U401.9 (XTAL1/PB6), Y401.2
unnamed: C403.1, U401.10 (XTAL2/PB7), Y401.1
unnamed: R411.2, U401.1 (~RESET/PC6)

Notes on the sheet:
http://ww1.microchip.com/downloads/en/appnotes/atmel-2521-avr-hardware-design-considerations_applicationnote_avr042.pdf
Low-pass filter components shall be calculated according to control algorithm Cutoff = 1 / (2 * pi * R*C) 10k * 100nF results in cutoff frequency is 159Hz

Parts:
C301, C304: 1uF; CP_EIA-6032-20_AVX-F_Pad2.25x2.35mm_HandSolder
C302, C303: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D301: LL4148; D_MiniMELF_Handsoldering
U301: LM7805; TO-220-3_Horizontal_TabDown_SMD

Connections:
+5V: C303.1, C304.1, U301.3 (VO); also elsewhere on the board
unnamed: C301.1, C302.1, D301.1 (K), U301.1 (VI)
VCC: D301.2 (A); also elsewhere on the board

Parts:
J601, J602: RJ45; RJ45_YH59_01

Connections:
/CANBUS CONN/CAN_18V: J601.4, J601.5, J602.4, J602.5; also elsewhere on the board
/CANBUS CONN/CAN_H: J601.1, J602.1; also elsewhere on the board
/CANBUS CONN/CAN_L: J601.2, J602.2; also elsewhere on the board

Parts:
C601, C605, C611, C612, C629: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C602, C621: 4700uF; CP_Radial_D12.5mm_P5.00mm
C603, C608, C609, C610: 47u
C604, C628: 1uF; CP_EIA-6032-20_AVX-F_Pad2.25x2.35mm_HandSolder
C606, C607: 47nF; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C613, C614, C617, C618: 4.7u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C615, C616, C620, C622, C623, C624, C625, C626, C627: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C619: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: Zener 5V1; D_MiniMELF
D4, D5: BAT54J; D_SOD-323F
D601, D602, D603: LL4148; D_MiniMELF_Handsoldering
D604, D605, D606: ES2A; D_MiniMELF_Handsoldering
D607, D608: LED_RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DZ601, DZ602, DZ603, DZ604: 12V; D_MiniMELF_Handsoldering
F601: 10A; Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_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
F602: 15A; Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_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
J611: +BAT_IN; MountingHole_5.3mm_M5_Pad_Via
J612: -BAT_IN; MountingHole_5.3mm_M5_Pad_Via
J613: +BAT_OUT; MountingHole_5.3mm_M5_Pad_Via
J614: -BAT_OUT; MountingHole_5.3mm_M5_Pad_Via
K601: G5LE-1; Relay_SPDT_SANYOU_SRD_Series_Form_C
L601: 300uH; Inductor_Nocoupled
Q601, Q602: IRFP260N; TO-247-3_Horizontal_TabUp
Q603: BC857; SOT-23
Q604: BC847; SOT-23
R601: 50k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R602, R603: 4R7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R604, R605: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R606: 1,5mR; R_2512_6432Metric_Reversed
R607, R615: 10R; R_2512_6332Metric
R608, R617: 10R; R_2512_6332Metric_Pad1.52x3.35mm_HandSolder
R609: 20k; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R610: 5k6; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R611: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R612: 90R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R613: 15k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R614: 1k2; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R616, R618: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U601: LM5104MNOPB; SOIC-8_3.9x4.9mm_P1.27mm
U602: INA240A4D; SOIC-8_3.9x4.9mm_P1.27mm
U603: LM324; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C611.2, C612.2, U602.6 (V+), U603.4 (V+); also elsewhere on the board
+12V: C604.1, C605.1, D601.2 (A), U601.1 (VDD); also elsewhere on the board
/MCU/ENABLE: Q604.1 (B), R616.1; also elsewhere on the board
/MCU/INALLL: U602.5; also elsewhere on the board
/MCU/LM324_A: U603.1, U603.2 (-); also elsewhere on the board
/MCU/LM324_B: U603.6 (-), U603.7; also elsewhere on the board
/MCU/PWM: U601.6 (IN); also elsewhere on the board
/driver/GATE_HS: D603.2 (A), DZ603.2 (A), Q601.1 (G), R603.1, R605.2
/driver/GATE_LS: D602.2 (A), DZ601.2 (A), Q602.1 (G), R602.1, R604.2
/driver/HIGH_SOURCE: C601.2, C606.2, D605.2 (A), DZ604.2 (A), Q601.3 (S), Q602.2 (D), Q602.4 (D), R605.1, R606.2, R608.2, R617.2, U601.4 (HS), U602.8 (+)
/driver/Shunt-: L601.1, R606.1, U602.1 (-)
/driver/bat_in_-: R614.1
/driver/bat_out+: R609.2
/driver/bat_out_+: F602.1, K601.3, R618.1
/driver/relay_coil: D606.1 (K), K601.2, R612.1
unnamed: C603.1, C608.1, C609.1, C610.1, C617.1, C618.1, C619.1, C620.1, K601.1, L601.2
unnamed: D1.1 (K), D4.1 (K), R613.1, R614.2, U603.5 (+)
unnamed: D2.1 (K), D5.1 (K), R609.1, R610.2, U603.3 (+)
unnamed: C601.1, D601.1 (K), U601.2 (HB)
unnamed: D602.1 (K), R602.2, U601.8 (LO)
unnamed: D603.1 (K), R603.2, U601.3 (HO)
unnamed: C606.1, D604.1 (K), R607.1, R615.1
unnamed: C607.1, D605.1 (K), R608.1, R617.1
unnamed: D607.2 (A), R616.2
unnamed: D608.2 (A), R618.2
unnamed: DZ601.1 (K), DZ602.1 (K)
unnamed: DZ603.1 (K), DZ604.1 (K)
unnamed: F601.2, J611.1
unnamed: F602.2, J613.1
unnamed: Q603.1 (B), Q604.3 (C)
unnamed: Q603.3 (C), R612.2
unnamed: Q604.2 (E), R611.2
unnamed: R601.1, U601.5 (RT)
unnamed: U603.8, U603.9 (-)
unnamed: U603.13 (-), U603.14
VCC: C628.1, C629.1, Q603.2 (E); also elsewhere on the board

Notes on the sheet:
DRIVER
ANALOG
BUCK CONVERTER
RELAY ACTIVATION

Parts:
C501, C504: 1uF; CP_EIA-6032-20_AVX-F_Pad2.25x2.35mm_HandSolder
C502, C503: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D501: LL4148; D_MiniMELF_Handsoldering
U501: LM7812; TO-220-3_Horizontal_TabDown_SMD

Connections:
+12V: C503.1, C504.1, U501.3 (VO); also elsewhere on the board
unnamed: C501.1, C502.1, D501.1 (K), U501.1 (VI)
VCC: D501.2 (A); also elsewhere on the board

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
Board: 2 copper layers, 172.8 x 81.5 mm, 144 parts (80 on the bottom side), 68 nets.

File hardware/bom/MCB19-bom.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet
1,"Unpolarized capacitor, small symbol",C_Small,C203 C204 C403 C404,22pF,C_0805_2012Metric_Pad1.15x1.40mm_HandSolder,4,
2,"Unpolarized capacitor, small symbol",C_Small,C606 C607,47nF,C_1210_3225Metric_Pad1.42x2.65mm_HandSolder,2,~
3,"Unpolarized capacitor, small symbol",C_Small,C201 C202 C205 C302 C303 C401 C402 C406 C407 C408 C409 C502 C503 C601 C605 C611 C612 C615 C616 C619 C620 C622 C623 C624 C625 C626 C627 C629,100nF,C_0805_2012Metric_Pad1.15x1.40mm_HandSolder,28,
4,"Polarized capacitor, small US symbol",CP1_Small,C301 C304 C501 C504 C604 C628,1uF,CP_EIA-6032-20_AVX-F_Pad2.25x2.35mm_HandSolder,6,
5,"Unpolarized capacitor, small symbol",C_Small,C613 C614 C617 C618,4.7u,C_1206_3216Metric_Pad1.42x1.75mm_HandSolder,4,~
6,"Polarized capacitor, small US symbol",CP1_Small,C603 C608 C609 C610,47uF,CP_Radial_D12.5mm_P5.00mm,4,~
7,"Polarized capacitor, small US symbol",CP1_Small,C602 C621,4700uF,CP_Radial_D12.5mm_P5.00mm,2,~
8,"100V 0.15A standard switching diode, MiniMELF",LL4148,D604 D605 D606,ES2A,D_MiniMELF_Handsoldering,3,http://www.vishay.com/docs/85557/ll4148.pdf
9,"Light emitting diode, small symbol",LED_Small,D402 D403 D607 D608,LED_RED,LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder,4,
10,"100V 0.15A standard switching diode, MiniMELF",LL4148,D301 D401 D501 D601 D602 D603,LL4148,D_MiniMELF_Handsoldering,6,https://www.vishay.com/docs/85557/ll4148.pdf
11,"Bidirectional dual transient-voltage-suppression diode, center on pin 3",D_TVS_x2_AAC,D201,pesd1can,SOT-23_Handsoldering,1,https://assets.nexperia.com/documents/data-sheet/PESD1CAN.pdf
12,"Zener diode, small symbol",D_Zener_Small,DZ601 DZ602 DZ603 DZ604,12V,D_MiniMELF_Handsoldering,4,~
13,Fuse,Fuse,F601,10A,Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_Open,1,~
14,Fuse,Fuse,F602,15A,Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_Open,1,~
15,"Fuse, small symbol",Fuse_Small,F501,500mA,Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder,1,~
16,"Generic screw terminal, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)",Screw_Terminal_01x01,J611 J612 J613 J614,+BAT_IN,MountingHole_5.3mm_M5_Pad_Via,4,~
17,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x02_Male,J402,DISABLE,PinSocket_1x02_P2.54mm_Vertical,1,~
18,"RJ connector, 8P8C (8 positions 8 connected), Shielded",RJ45_Shielded,J601 J602,RJ45,RJ45_YH59_01,2,
19,"Generic connector, single row, 01x04, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x04,J401,USART,PinHeader_1x04_P2.54mm_Vertical,1,~
20,"Omron G5LE relay, Miniature Single Pole, SPDT, 10A",G5LE-1,K601,G5LE-1,Relay_SPDT_SANYOU_SRD_Series_Form_C,1,http://www.omron.com/ecb/products/pdf/en-g5le.pdf
21,Inductor,L,L601,300uH,Inductor_Nocoupled,1,~
22,"0.1A Ic, 45V Vce, NPN Transistor, SOT-23",BC847,Q604,BC847,SOT-23,1,http://www.infineon.com/dgdl/Infineon-BC847SERIES_BC848SERIE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
23,"0.1A Ic, 45V Vce, PNP Transistor, SOT-23",BC857,Q603,BC857,SOT-23,1,http://www.fairchildsemi.com/ds/BC/BC856.pdf
24,"N-MOSFET transistor, gate/drain/source, drain connected to mounting plane",Q_NMOS_GDSD,Q601 Q602,IRFP260N,TO-247-3_Horizontal_TabUp,2,~
25,"Resistor, small symbol",R_Small,R606,"1,5mR",R_2512_6432Metric_Reversed,1,~
26,"Resistor, small symbol",R_Small,R602 R603,4R7,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,2,~
27,"Resistor, small symbol",R_Small,R607 R615,10R,R_2512_6332Metric,2,~
28,"Resistor, small symbol",R_Small,R608 R617,10R,R_2512_6332Metric_Pad1.52x3.35mm_HandSolder,2,~
29,"Resistor, small symbol",R_Small,R612,90R,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,1,~
30,"Resistor, small symbol",R_Small,R411,100,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,1,
31,"Resistor, small symbol",R_Small,R404 R406 R616 R618,330,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,4,~
32,"Resistor, small symbol",R_Small,R407 R408 R409,680,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,3,~
33,"Resistor, small symbol",R_Small,R201 R402 R403 R611,1k,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,4,
34,"Resistor, small symbol",R_Small,R610 R614,1k2,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,2,~
35,"Resistor, small symbol",R_Small,R202,4k7,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,1,
36,"Resistor, small symbol",R_Small,R203 R401 R410 R604 R605,10k,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,5,
37,"Resistor, small symbol",R_Small,R609 R613,15k,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,2,~
38,"Resistor, small symbol",R_Small,R601,50k,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,1,~
39,"20MHz, 32kB Flash, 2kB SRAM, 1kB EEPROM, DIP-28",ATmega328P-PU,U401,ATMEGA328P-PU,DIP-28_W7.62mm_Socket,1,http://ww1.microchip.com/downloads/en/DeviceDoc/Atmel-8025-8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
40,"High- and Low-Side, Bidirectional, Zero-Drift, Current-Sense Amplifier With Enhanced PWM Rejection, 200V/V, SOIC-8",INA240A4D,U602,INA240A4D,SOIC-8_3.9x4.9mm_P1.27mm,1,http://www.ti.com/lit/ds/symlink/ina240.pdf
41,"Low-Power, Quad-Operational Amplifiers, DIP-14/SOIC-14/SSOP-14",LM324,U603,LM324,SOIC-14_3.9x8.7mm_P1.27mm,1,http://www.ti.com/lit/ds/symlink/lm2902-n.pdf
42,,LM5104MNOPB-INA211BIDCKR,U601,LM5104MNOPB,SOIC-8_3.9x4.9mm_P1.27mm,1,
43,"Positive 1A 35V Linear Regulator, Fixed Output 5V, TO-220",LM7805_TO220,U301,LM7805,TO-220-3_Horizontal_TabDown_SMD,1,https://www.sparkfun.com/datasheets/Components/LM7805.pdf
44,"Positive 1A 35V Linear Regulator, Fixed Output 5V, TO-220",LM7805_TO220,U501,LM7812,TO-220-3_Horizontal_TabDown_SMD,1,https://www.sparkfun.com/datasheets/Components/LM7805.pdf
45,"Stand-Alone CAN Controller with SPI Interface, SOIC-18",MCP2515-xSO,U202,MCP2515-xSO,SOIC-18W_7.5x11.6mm_P1.27mm,1,http://ww1.microchip.com/downloads/en/DeviceDoc/21801e.pdf
46,"High-Speed CAN Transceiver, 1Mbps, 5V supply, SPLIT pin, -40C to +125C, SOIC-8",MCP2561-E-SN,U201,MCP2551-I/SN,SOIC-8_3.9x4.9mm_P1.27mm,1,http://ww1.microchip.com/downloads/en/DeviceDoc/25167A.pdf
47,"Two pin crystal, small symbol",Crystal_Small,Y201 Y401,16MHz,Crystal_HC49-U_Vertical,2,http://www.farnell.com/datasheets/321153.pdf

Component Groups:,47
Component Count:,126
Fitted Components:,126
Number of PCBs:,1
Total components:,126
Schematic Version:,
Schematic Date:,
PCB Variant:,default
BoM Date:,Fri Mar  4 12:24:29 2022
Schematic Source:,MCB19.sch
KiCad Version:,Eeschema 5.1.9+dfsg1-1~bpo10+1
